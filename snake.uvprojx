# Keil uVision project snake.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x0007F800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: snake +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Application;.\BSP;.\Core
  asm include: .\Application;.\BSP;.\Core
  memory RVCT4: ROM 0x8000000 size 0x7f800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./Application/: main.c snake_game.c flash_store.c chinese_fonts.c title_bitmap.c
  group BSP
    ./BSP/: bsp_led.c bsp_usart.c bsp_lcd_game.c bsp_beep_led.c bsp_key.c bsp_ps2.c bsp_touch.c
  group Core
    ./Core/: startup_stm32f103ve.s system_stm32f10x.c delay.c
